# Keil uVision project project.uvprojx, settings and files
target Target 1 (5060750::V5.06 update 6 (build 750)::ARMCC)
  device: STM32F407VETx STMicroelectronics
  pack: Keil.STM32F4xx_DFP.2.14.0
  cpu: IRAM(0x20000000,0x20000) IRAM2(0x10000000,0x10000) IROM(0x08000000,0x80000) CPUTYPE("Cortex-M4") FPU2 CLOCK(12000000) ELITTLE
  output: project +hex
  c flags: Optim=1 v6Lang=1 v6LangP=1 wLevel=2
  c define: STM32F40_41xxx USE_STDPERIPH_DRIVER,ARM_MATH_CM4,__FPU_PRESENT
  c misc: --c99
  c include: ..\APP;..\BSP;..\Libraries\inc;..\Libraries\src;..\Libraries\cmsis\Include;..\Libraries\cmsis;..\SYSTEM;..\task;..\BMI
  memory RVCT4: ROM 0x8000000 size 0x80000
  memory RVCT9: RAM 0x20000000 size 0x20000
  memory RVCT10: RAM 0x10000000 size 0x10000
  group APP
    ../APP/: main.c stm32f4xx_it.c system.c system.h pid.c 2ms_analy.c 2ms_analy.h kalman.c pid.h fuzzypid.c
  group BSP
    ../BSP/: can1.c can2.c control.c usart2.c led.c crc.c anoc.c
  group STM32_StdPeriph
    ../Libraries/src/: misc.c stm32f4xx_gpio.c stm32f4xx_rcc.c stm32f4xx_tim.c stm32f4xx_usart.c stm32f4xx_can.c stm32f4xx_dma.c stm32f4xx_exti.c stm32f4xx_flash.c stm32f4xx_spi.c stm32f4xx_adc.c stm32f4xx_syscfg.c
    ../Libraries/startup/: startup_stm32f40xx.s
    ../Libraries/cmsis/: system_stm32f4xx.c
  group SYSTEM
    ../SYSTEM/: usart.c sys.c my_include.h
  group Task
    ../task/: Task_chassis.c Task_gimble.c remote.c Task_stand.c Task_momentum.c Choose_Task.c
  group BMI
    ../BMI/: bmi.c bmi2.c bmi2_common.c bmi2_ois.c bmi270.c bmi270_context.c iic.c myiic.c spi2.c
